Commit message: Update from tsukuba test

File: catkin_ws/src/scripts/urdf/robot_org.urdf (robot description, URDF)
Before this commit: robot ter2, 4 links, 3 joints
Joints:
- joint laser3d_link_joint: origin xyz=0.09 0.00 0.83 rpy=0. 0. -1.661 -> xyz=0.09 0.00 0.83 rpy=0. 0. -1.571
