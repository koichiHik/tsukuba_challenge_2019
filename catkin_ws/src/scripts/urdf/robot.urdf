Commit message: Update...

File: catkin_ws/src/scripts/urdf/robot.urdf (robot description, URDF)
Before this commit: robot ter2, 4 links, 3 joints
Joints:
- joint laser2d_link_joint: origin xyz=0.22 0.00 0.17 rpy=0.0 0.0 0.0 -> xyz=0.22 0.00 0.21 rpy=0.0 0.0 0.0
